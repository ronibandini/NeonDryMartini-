// Dry Martini Neon Sign
// Roni Bandini @RoniBandini 
// Argentina, May 2022


#include <WiFi.h>


// relay
int pinRelay=D3;
int relayStatus=0;

// WiFi
const char* ssid     = "SSID";
const char* password = "PASSWORD";

// Set web server port number to 80
WiFiServer server(80);

// Variable to store the HTTP request
String header;


void relayOn(){
    digitalWrite(pinRelay, LOW);
    Serial.println("Relay on");
    relayStatus=1;
  
}

void relayOff(){
    digitalWrite(pinRelay, HIGH);
    Serial.println("Relay off");
    relayStatus=0;    
}

// Time functions
unsigned long currentTime = millis();
unsigned long previousTime = 0; 
const long timeoutTime = 2000;


void setup() {
  
  pinMode(pinRelay, OUTPUT);
  
  delay(2000);
  Serial.begin(115200); 
  Serial.println("Dry Martini Neon Sign started...");         

  Serial.print(" - connecting to ");
  Serial.println(ssid);
  WiFi.begin(ssid, password);
    
  while (WiFi.status() != WL_CONNECTED) {
      delay(500);
      Serial.print(".");
    }    

  Serial.println("");
  Serial.println("Server IP: ");
  Serial.println(WiFi.localIP());
  server.begin();

  relayOn();
  delay(500);
  relayOff();
  
}

  
void loop() {

 WiFiClient client = server.available();    

  if (client) {                             
    currentTime = millis();
    previousTime = currentTime;
    Serial.println("New Client.");           
    String currentLine = "";                
    
    while (client.connected() && currentTime - previousTime <= timeoutTime) {   
      currentTime = millis();
      
      if (client.available()) {             
        char c = client.read();             
        Serial.write(c);                     
        header += c;
       
        if (c == '\n') {                    
                   
          if (currentLine.length() == 0) {           
            client.println("HTTP/1.1 200 OK");
            client.println("Content-type:text/html");
            client.println("Connection: close");
            client.println();
            
            if (header.indexOf("GET /relay/on") >= 0) {              
              relayOn();              
            } else if (header.indexOf("GET /relay/off") >= 0) {
              relayOff();
            }                           
            
            // Display the HTML web page
            client.println("<!DOCTYPE html><html>");
            client.println("<head><meta name=\"viewport\" content=\"width=device-width, initial-scale=1\">");
            client.println("<link rel=\"icon\" href=\"data:,\">");
            // CSS to style the on/off buttons 
            // Feel free to change the background-color and font-size attributes to fit your preferences
            client.println("<style>html { font-family: Helvetica; display: inline-block; margin: 0px auto; text-align: center;}");
            client.println(".button { background-color: #4CAF50; border: none; color: white; padding: 16px 40px;");
            client.println("text-decoration: none; font-size: 30px; margin: 2px; cursor: pointer;}");
            client.println(".button2 {background-color: #555555;}</style></head>");
            
            client.println("<body><h1>Neon Dry Martini</h1>");
            client.println("<img src='data:image/jpeg;base64,/9j/4Q20RXhpZgAATU0AKgAAAAgADAEAAAMAAAABAMgAAAEBAAMAAAABAR4AAAECAAMAAAADAAAAngEGAAMAAAABAAIAAAESAAMAAAABAAEAAAEVAAMAAAABAAMAAAEaAAUAAAABAAAApAEbAAUAAAABAAAArAEoAAMAAAABAAIAAAExAAIAAAAcAAAAtAEyAAIAAAAUAAAA0IdpAAQAAAABAAAA5AAAARwACAAIAAgACvyAAAAnEAAK/IAAACcQQWRvYmUgUGhvdG9zaG9wIENTNSBXaW5kb3dzADIwMjI6MDU6MDMgMTY6NTM6MDAAAASQAAAHAAAABDAyMjGgAQADAAAAAQABAACgAgAEAAAAAQAAAGSgAwAEAAAAAQAAAI8AAAAAAAAABgEDAAMAAAABAAYAAAEaAAUAAAABAAABagEbAAUAAAABAAABcgEoAAMAAAABAAIAAAIBAAQAAAABAAABegICAAQAAAABAAAMMgAAAAAAAABIAAAAAQAAAEgAAAAB/9j/7QAMQWRvYmVfQ00AAf/uAA5BZG9iZQBkgAAAAAH/2wCEAAwICAgJCAwJCQwRCwoLERUPDAwPFRgTExUTExgRDAwMDAwMEQwMDAwMDAwMDAwMDAwMDAwMDAwMDAwMDAwMDAwBDQsLDQ4NEA4OEBQODg4UFA4ODg4UEQwMDAwMEREMDAwMDAwRDAwMDAwMDAwMDAwMDAwMDAwMDAwMDAwMDAwMDP/AABEIAI8AZAMBIgACEQEDEQH/3QAEAAf/xAE/AAABBQEBAQEBAQAAAAAAAAADAAECBAUGBwgJCgsBAAEFAQEBAQEBAAAAAAAAAAEAAgMEBQYHCAkKCxAAAQQBAwIEAgUHBggFAwwzAQACEQMEIRIxBUFRYRMicYEyBhSRobFCIyQVUsFiMzRygtFDByWSU/Dh8WNzNRaisoMmRJNUZEXCo3Q2F9JV4mXys4TD03Xj80YnlKSFtJXE1OT0pbXF1eX1VmZ2hpamtsbW5vY3R1dnd4eXp7fH1+f3EQACAgECBAQDBAUGBwcGBTUBAAIRAyExEgRBUWFxIhMFMoGRFKGxQiPBUtHwMyRi4XKCkkNTFWNzNPElBhaisoMHJjXC0kSTVKMXZEVVNnRl4vKzhMPTdePzRpSkhbSVxNTk9KW1xdXl9VZmdoaWprbG1ub2JzdHV2d3h5ent8f/2gAMAwEAAhEDEQA/APVUlW6lflY+DdfiUfacithdXRO3eR+buhy5jp31r+s/VMRuZg9HotpeS0H7U1pDmmHMexzNzHtSU9gkuY/bP10/8o6f/Ytv/kUv2z9dP/KOn/2Lb/5FJT06S5n9s/XT/wAo6f8A2Lb/AORTftn66f8AlHT/AOxbf/IpKenSXM/tn66f+UdP/sW3/wAil+2frrx+wqf/AGLb/wCRSU9MuY+t31ryeh3Y2LiUV23ZDH2l97iysNr5Y0j6Vrkz+u/XBjHvf0XHaysFz3HMZDQNXOd7VzzH9d+s+Wzrd/Rqs7ADDVh4tt4ZW0g/pcj3jddvc36exA+CR4vd9F6k3qvSsXqLWGoZNYf6Z1gnkSry5dnVfrjWxtdfQcdjGANa1uUwAAcNaA1Af9a/rHT1PE6bk9Hqbfmn2MZkh7gwfzlr9jDsrZ+85G1U9ekkkkh//9D1Vchns/5r9b/aTBHReqvDc5o4oyDpXlj92u7/AAq69AzcLHz8S3DymCyi9pZYw9wUlPIZPX/rSOv39IxqMJpaPVxTcbB6tJ+jZW9rtr3/AOkR/tX18j+Y6b/nWrKs6fmknoFtm3rnRv1noWY7Q344/wC07j+d7f0VjV0XROr1dXwGZTG+na0mvIoPNdrdLK3D/qVT5rLmx1KNcB7j5ZMsIxO+7S+1/X2f5jpv+fal9q+vv+g6b/nWrc/1KSq/fs3h9jJ7UXD+1fX3/QdN/wA+1c/136x9aOYekdZyKun0saLb3YO8vsDh7Mdtjpc3d/JXS9f69+y/Rx8en7V1DKkUUTAgfStud+bU1cU63rnUupX9ULMe2/GP2ayqsENeG+79G9273Mn6amx8xmlEmRAFafoyWmMY1Kro9fl8ldN+r9GVgPsu9XHtvc81nedwqP8ANtub+et7oHV/rffiOxMKnAczpzvsrjZvYTsHtO2v2fQWbhZ/V+o76+m9OsdbW7ZY+xzRXW//AIVy0Dh5fT8Wr6s4Fvq9Z6s512dkt4qrdpfd/J9n6KlKGXPxGOnHMjhj8/CP0j/dWAXZls3ekfW3qD6upZ3V2Y7OndOmsX45dFlwP8zR6h/S/urT+qnS8kuu+sHVWx1PqIBbWf8AAY/NOM3932+61ZPSOmYvV86nExW/9jnQHbah2yctv07X/wCkrpd/013KvjxWHwUkkkih/9H1VJJJJTifWjolvUsWvJwXel1XAd62Db/KH0qH/wDB3/QXLM6mzHtZ9asVhrxMpwxvrBhjmm9p2fadn8l30l6IuP8ArFhs6L1F/W21+r0nqAFHXMaJbDvZXm7f5O7bamTgJxMZagpia2dxj2PY17HBzXAOY4agg/RcEPKy8bDx35OVa2misS+x5gLB6Hc/o+cfq7k2erjWNN3R8kmRZSfd9n3fv0/mqh9fH5Rz+lUsrbbQTY8VWHbW+1sbPU/qt+isk8uRlOORoam+8R6myJggFxvrH1jpvVutVZeO/Ibi10+jda1pr2y5zmOnV3p2bldxc7o2BiBtV9bKG66OBJJ7/vveidMxbavtF+Y5tmTmOBtDR7AGjayprT+a1F+q/Tumu691Q/ZqbKMdtTmve0OFdh3GxrC72tUkpQkCAZcOMDSJsS/lxMJ9UqvRJ0TM/ZXTup/WLMrdXVnWNOHjnR9m0Gur2fvZDymZjdSrjpzHf9kv1h/S59w1+yYn7g/c2s9jP5f9hTu6lRm5Fv1lzAX9H6U41dKx++TlfR9Vrfzvd7al0n1V6NkYlV3U+p+7q/UiLMp3+jb/AILEZ/IparnL4uEGchUp1/gw/RiiR6DYOp03p2L0zBpwMRuyihoa0dz+8938t7vc5WkklZWKSSSSU//S9VSSSSUpDvoqyKX0XtFlVrSyxjtQWuEOaURJJT57d0m2ux31UyLSy6knL+rWe46jb7jiOf8AvV/Q/qK2LavrN9X8inKxt/UsTcy7F3bHsyWA7HVv/wAH6n5q6D6y9EHWOn+nW70c3Hd62FkDmu1v0Nf3H/QsXIuz7xH1poqNeZiH7J9ZMBogw32/ams/eZ9NV+YxGcRKPzw1j/3q+Eq32LLD+pfVXY1Tcvq9tbi0erVWxpLSeWNyHO/6SnlYVFZr+qHRCaRcPW6rlky5lH+EdbZ/p8j/AKhbPVuvY+D0pufQRkOydrcGtupusf8AzTW/+jFh19NywW/Vuq0u6t1X9a+sGa3U1Un/ALTtd/Ln0q2qtysJZJGUxUIn5QOESn/6CvnwxFDct/oWFT1vqNWbXXs6B0b9D0mntZa322Zrh+ds/wAGu0QcPEx8LFqxMZgrooaGVsHAARlosKkkkklKSSSSU//T9VSSSSUpJJJJSlyfXaWdH+sOL1drR9j6qRgdTZ+aS4Ri3ub/AOBvXWLB+vVAu+qufp7qaxcw+Dq3NtDv+igVBoH6ufV/6vC7rQZY4YDH201W2F9dRj/tPW76Dnu9qu/U3p1tHTndSzNeo9Wd9qyXnkB2tFI/kVVLO+tl7sv6s4dYP/Kd2JU/zFhbY/8A6ldg1oa0NaIAEAeQSSukkkihSSSSSlJJJJKf/9T1VJJJJSkkkklKWT9bP/Ez1T/wrb/1JWssn61/+Jrqn/hW3/qSkp5/q3/IX1Z/8N4H/UrtlxPVf+Qvqz/4bwP+pXbJBKkkkkkKSSSSUpJJJJT/AP/V9VSSSSUpJJJJSlk/Wz/xM9U/8K2/9SVrLJ+tf/ia6p/4Vt/6kpKef6r/AMhfVn/w3gf9Su2XE9V/5C+rP/hvA/6ldskEqSSSSQpJJJJSkkkklP8A/9b1VJJJJSkklU6l1Xp3S8c5PUMhmPV2LzqT+6xv0nu/qJKbayfrZ/4meqf+Fbf+pKzP+dXWOo/8g9IstpP0czNd6FR/lMrP6WxBzOmfXTqmNbi5vUMPFoyGFllVFLnna4Q5vqWlBVIOq/8AIX1Z/wDDeB/1K7Zc31T6v25nSMHBx8r7Pd099NlN7mbwXUN2M3V7kKfr9iattwOptH5jmvof8nD9Gkl6lJczV9da8axtH1gwbukWOMNuePUx3H+Tk1f9+XR03VX1ttpe2yt4lj2EOaR4tc1FDNJJJJSkkkklP//X9VSSSSU5H1o627ofSH5zKxZaXNqqa4wwPsO1r7nfm1M/PXNdMf8AVcZA6n1vrGL1Pqrtd77Gmqr/AIPEo+g1rf3122X9k+zv+2+n9nj9J60bI/l+p7FlR9Tf/Nd/4Ckph/zq+rXfqmLP/GBN/wA6vqz/AOWmLH/GBEj6m/8Amu++lKPqb/5rv/AUrPgrRH/zq+rP/lpi/wDbgS/51fVn/wAtMWP+MCJH1M/81330p4+pv/mu/wDAUrPgrRBb9ZvqpdW6q7qOJZW8Q5j3tc0j+U1y5u/qfSPq7Y7qH1b6nRbiEzldGNu5rgT7rMH/AEVv8hdVH1M/81330p2j6n7ht/Z26Rtj0ZntCCXWotbdTXc0ENsaHgHQw4btURJJFCkkkklP/9n/7RTMUGhvdG9zaG9wIDMuMAA4QklNBAQAAAAAAA8cAVoAAxslRxwCAAACzHQAOEJJTQQlAAAAAAAQdRhuUxXp1b1XdNrUw8EZxThCSU0EOgAAAAAA1wAAABAAAAABAAAAAAALcHJpbnRPdXRwdXQAAAAEAAAAAFBzdFNib29sAQAAAABJbnRlZW51bQAAAABJbnRlAAAAAENscm0AAAAPcHJpbnRTaXh0ZWVuQml0Ym9vbAAAAAALcHJpbnRlck5hbWVURVhUAAAAMQBIAGUAdwBsAGUAdAB0AC0AUABhAGMAawBhAHIAZAAgAEgAUAAgAEwAYQBzAGUAcgBKAGUAdAAgAFAAcgBvAGYAZQBzAHMAaQBvAG4AYQBsACAAUAAgADEAMQAwADIAdwAAADhCSU0EOwAAAAABsgAAABAAAAABAAAAAAAScHJpbnRPdXRwdXRPcHRpb25zAAAAEgAAAABDcHRuYm9vbAAAAAAAQ2xicmJvb2wAAAAAAFJnc01ib29sAAAAAABDcm5DYm9vbAAAAAAAQ250Q2Jvb2wAAAAAAExibHNib29sAAAAAABOZ3R2Ym9vbAAAAAAARW1sRGJvb2wAAAAAAEludHJib29sAAAAAABCY2tnT2JqYwAAAAEAAAAAAABSR0JDAAAAAwAAAABSZCAgZG91YkBv4AAAAAAAAAAAAEdybiBkb3ViQG/gAAAAAAAAAAAAQmwgIGRvdWJAb+AAAAAAAAAAAABCcmRUVW50RiNSbHQAAAAAAAAAAAAAAABCbGQgVW50RiNSbHQAAAAAAAAAAAAAAABSc2x0VW50RiNQeGxAUgAAAAAAAAAAAAp2ZWN0b3JEYXRhYm9vbAEAAAAAUGdQc2VudW0AAAAAUGdQcwAAAABQZ1BDAAAAAExlZnRVbnRGI1JsdAAAAAAAAAAAAAAAAFRvcCBVbnRGI1JsdAAAAAAAAAAAAAAAAFNjbCBVbnRGI1ByY0BZAAAAAAAAOEJJTQPtAAAAAAAQAEgAAAABAAEASAAAAAEAAThCSU0EJgAAAAAADgAAAAAAAAAAAAA/gAAAOEJJTQPyAAAAAAAKAAD///////8AADhCSU0EDQAAAAAABAAAAHg4QklNBBkAAAAAAAQAAAAeOEJJTQPzAAAAAAAJAAAAAAAAAAABADhCSU0nEAAAAAAACgABAAAAAAAAAAI4QklNA/UAAAAAAEgAL2ZmAAEAbGZmAAYAAAAAAAEAL2ZmAAEAoZmaAAYAAAAAAAEAMgAAAAEAWgAAAAYAAAAAAAEANQAAAAEALQAAAAYAAAAAAAE4QklNA/gAAAAAAHAAAP////////////////////////////8D6AAAAAD/////////////////////////////A+gAAAAA/////////////////////////////wPoAAAAAP////////////////////////////8D6AAAOEJJTQQIAAAAAAAQAAAAAQAAAkAAAAJAAAAAADhCSU0EHgAAAAAABAAAAAA4QklNBBoAAAAAA0kAAAAGAAAAAAAAAAAAAACPAAAAZAAAAAoARAByAHkATQBhAHIAdABpAG4AaQAAAAEAAAAAAAAAAAAAAAAAAAAAAAAAAQAAAAAAAAAAAAAAZAAAAI8AAAAAAAAAAAAAAAAAAAAAAQAAAAAAAAAAAAAAAAAAAAAAAAAQAAAAAQAAAAAAAG51bGwAAAACAAAABmJvdW5kc09iamMAAAABAAAAAAAAUmN0MQAAAAQAAAAAVG9wIGxvbmcAAAAAAAAAAExlZnRsb25nAAAAAAAAAABCdG9tbG9uZwAAAI8AAAAAUmdodGxvbmcAAABkAAAABnNsaWNlc1ZsTHMAAAABT2JqYwAAAAEAAAAAAAVzbGljZQAAABIAAAAHc2xpY2VJRGxvbmcAAAAAAAAAB2dyb3VwSURsb25nAAAAAAAAAAZvcmlnaW5lbnVtAAAADEVTbGljZU9yaWdpbgAAAA1hdXRvR2VuZXJhdGVkAAAAAFR5cGVlbnVtAAAACkVTbGljZVR5cGUAAAAASW1nIAAAAAZib3VuZHNPYmpjAAAAAQAAAAAAAFJjdDEAAAAEAAAAAFRvcCBsb25nAAAAAAAAAABMZWZ0bG9uZwAAAAAAAAAAQnRvbWxvbmcAAACPAAAAAFJnaHRsb25nAAAAZAAAAAN1cmxURVhUAAAAAQAAAAAAAG51bGxURVhUAAAAAQAAAAAAAE1zZ2VURVhUAAAAAQAAAAAABmFsdFRhZ1RFWFQAAAABAAAAAAAOY2VsbFRleHRJc0hUTUxib29sAQAAAAhjZWxsVGV4dFRFWFQAAAABAAAAAAAJaG9yekFsaWduZW51bQAAAA9FU2xpY2VIb3J6QWxpZ24AAAAHZGVmYXVsdAAAAAl2ZXJ0QWxpZ25lbnVtAAAAD0VTbGljZVZlcnRBbGlnbgAAAAdkZWZhdWx0AAAAC2JnQ29sb3JUeXBlZW51bQAAABFFU2xpY2VCR0NvbG9yVHlwZQAAAABOb25lAAAACXRvcE91dHNldGxvbmcAAAAAAAAACmxlZnRPdXRzZXRsb25nAAAAAAAAAAxib3R0b21PdXRzZXRsb25nAAAAAAAAAAtyaWdodE91dHNldGxvbmcAAAAAADhCSU0EKAAAAAAADAAAAAI/8AAAAAAAADhCSU0EFAAAAAAABAAAAAI4QklNBAwAAAAADE4AAAABAAAAZAAAAI8AAAEsAACnlAAADDIAGAAB/9j/7QAMQWRvYmVfQ00AAf/uAA5BZG9iZQBkgAAAAAH/2wCEAAwICAgJCAwJCQwRCwoLERUPDAwPFRgTExUTExgRDAwMDAwMEQwMDAwMDAwMDAwMDAwMDAwMDAwMDAwMDAwMDAwBDQsLDQ4NEA4OEBQODg4UFA4ODg4UEQwMDAwMEREMDAwMDAwRDAwMDAwMDAwMDAwMDAwMDAwMDAwMDAwMDAwMDP/AABEIAI8AZAMBIgACEQEDEQH/3QAEAAf/xAE/AAABBQEBAQEBAQAAAAAAAAADAAECBAUGBwgJCgsBAAEFAQEBAQEBAAAAAAAAAAEAAgMEBQYHCAkKCxAAAQQBAwIEAgUHBggFAwwzAQACEQMEIRIxBUFRYRMicYEyBhSRobFCIyQVUsFiMzRygtFDByWSU/Dh8WNzNRaisoMmRJNUZEXCo3Q2F9JV4mXys4TD03Xj80YnlKSFtJXE1OT0pbXF1eX1VmZ2hpamtsbW5vY3R1dnd4eXp7fH1+f3EQACAgECBAQDBAUGBwcGBTUBAAIRAyExEgRBUWFxIhMFMoGRFKGxQiPBUtHwMyRi4XKCkkNTFWNzNPElBhaisoMHJjXC0kSTVKMXZEVVNnRl4vKzhMPTdePzRpSkhbSVxNTk9KW1xdXl9VZmdoaWprbG1ub2JzdHV2d3h5ent8f/2gAMAwEAAhEDEQA/APVUlW6lflY+DdfiUfacithdXRO3eR+buhy5jp31r+s/VMRuZg9HotpeS0H7U1pDmmHMexzNzHtSU9gkuY/bP10/8o6f/Ytv/kUv2z9dP/KOn/2Lb/5FJT06S5n9s/XT/wAo6f8A2Lb/AORTftn66f8AlHT/AOxbf/IpKenSXM/tn66f+UdP/sW3/wAil+2frrx+wqf/AGLb/wCRSU9MuY+t31ryeh3Y2LiUV23ZDH2l97iysNr5Y0j6Vrkz+u/XBjHvf0XHaysFz3HMZDQNXOd7VzzH9d+s+Wzrd/Rqs7ADDVh4tt4ZW0g/pcj3jddvc36exA+CR4vd9F6k3qvSsXqLWGoZNYf6Z1gnkSry5dnVfrjWxtdfQcdjGANa1uUwAAcNaA1Af9a/rHT1PE6bk9Hqbfmn2MZkh7gwfzlr9jDsrZ+85G1U9ekkkkh//9D1Vchns/5r9b/aTBHReqvDc5o4oyDpXlj92u7/AAq69AzcLHz8S3DymCyi9pZYw9wUlPIZPX/rSOv39IxqMJpaPVxTcbB6tJ+jZW9rtr3/AOkR/tX18j+Y6b/nWrKs6fmknoFtm3rnRv1noWY7Q344/wC07j+d7f0VjV0XROr1dXwGZTG+na0mvIoPNdrdLK3D/qVT5rLmx1KNcB7j5ZMsIxO+7S+1/X2f5jpv+fal9q+vv+g6b/nWrc/1KSq/fs3h9jJ7UXD+1fX3/QdN/wA+1c/136x9aOYekdZyKun0saLb3YO8vsDh7Mdtjpc3d/JXS9f69+y/Rx8en7V1DKkUUTAgfStud+bU1cU63rnUupX9ULMe2/GP2ayqsENeG+79G9273Mn6amx8xmlEmRAFafoyWmMY1Kro9fl8ldN+r9GVgPsu9XHtvc81nedwqP8ANtub+et7oHV/rffiOxMKnAczpzvsrjZvYTsHtO2v2fQWbhZ/V+o76+m9OsdbW7ZY+xzRXW//AIVy0Dh5fT8Wr6s4Fvq9Z6s512dkt4qrdpfd/J9n6KlKGXPxGOnHMjhj8/CP0j/dWAXZls3ekfW3qD6upZ3V2Y7OndOmsX45dFlwP8zR6h/S/urT+qnS8kuu+sHVWx1PqIBbWf8AAY/NOM3932+61ZPSOmYvV86nExW/9jnQHbah2yctv07X/wCkrpd/013KvjxWHwUkkkih/9H1VJJJJTifWjolvUsWvJwXel1XAd62Db/KH0qH/wDB3/QXLM6mzHtZ9asVhrxMpwxvrBhjmm9p2fadn8l30l6IuP8ArFhs6L1F/W21+r0nqAFHXMaJbDvZXm7f5O7bamTgJxMZagpia2dxj2PY17HBzXAOY4agg/RcEPKy8bDx35OVa2misS+x5gLB6Hc/o+cfq7k2erjWNN3R8kmRZSfd9n3fv0/mqh9fH5Rz+lUsrbbQTY8VWHbW+1sbPU/qt+isk8uRlOORoam+8R6myJggFxvrH1jpvVutVZeO/Ibi10+jda1pr2y5zmOnV3p2bldxc7o2BiBtV9bKG66OBJJ7/vveidMxbavtF+Y5tmTmOBtDR7AGjayprT+a1F+q/Tumu691Q/ZqbKMdtTmve0OFdh3GxrC72tUkpQkCAZcOMDSJsS/lxMJ9UqvRJ0TM/ZXTup/WLMrdXVnWNOHjnR9m0Gur2fvZDymZjdSrjpzHf9kv1h/S59w1+yYn7g/c2s9jP5f9hTu6lRm5Fv1lzAX9H6U41dKx++TlfR9Vrfzvd7al0n1V6NkYlV3U+p+7q/UiLMp3+jb/AILEZ/IparnL4uEGchUp1/gw/RiiR6DYOp03p2L0zBpwMRuyihoa0dz+8938t7vc5WkklZWKSSSSU//S9VSSSSUpDvoqyKX0XtFlVrSyxjtQWuEOaURJJT57d0m2ux31UyLSy6knL+rWe46jb7jiOf8AvV/Q/qK2LavrN9X8inKxt/UsTcy7F3bHsyWA7HVv/wAH6n5q6D6y9EHWOn+nW70c3Hd62FkDmu1v0Nf3H/QsXIuz7xH1poqNeZiH7J9ZMBogw32/ams/eZ9NV+YxGcRKPzw1j/3q+Eq32LLD+pfVXY1Tcvq9tbi0erVWxpLSeWNyHO/6SnlYVFZr+qHRCaRcPW6rlky5lH+EdbZ/p8j/AKhbPVuvY+D0pufQRkOydrcGtupusf8AzTW/+jFh19NywW/Vuq0u6t1X9a+sGa3U1Un/ALTtd/Ln0q2qtysJZJGUxUIn5QOESn/6CvnwxFDct/oWFT1vqNWbXXs6B0b9D0mntZa322Zrh+ds/wAGu0QcPEx8LFqxMZgrooaGVsHAARlosKkkkklKSSSSU//T9VSSSSUpJJJJSlyfXaWdH+sOL1drR9j6qRgdTZ+aS4Ri3ub/AOBvXWLB+vVAu+qufp7qaxcw+Dq3NtDv+igVBoH6ufV/6vC7rQZY4YDH201W2F9dRj/tPW76Dnu9qu/U3p1tHTndSzNeo9Wd9qyXnkB2tFI/kVVLO+tl7sv6s4dYP/Kd2JU/zFhbY/8A6ldg1oa0NaIAEAeQSSukkkihSSSSSlJJJJKf/9T1VJJJJSkkkklKWT9bP/Ez1T/wrb/1JWssn61/+Jrqn/hW3/qSkp5/q3/IX1Z/8N4H/UrtlxPVf+Qvqz/4bwP+pXbJBKkkkkkKSSSSUpJJJJT/AP/V9VSSSSUpJJJJSlk/Wz/xM9U/8K2/9SVrLJ+tf/ia6p/4Vt/6kpKef6r/AMhfVn/w3gf9Su2XE9V/5C+rP/hvA/6ldskEqSSSSQpJJJJSkkkklP8A/9b1VJJJJSkklU6l1Xp3S8c5PUMhmPV2LzqT+6xv0nu/qJKbayfrZ/4meqf+Fbf+pKzP+dXWOo/8g9IstpP0czNd6FR/lMrP6WxBzOmfXTqmNbi5vUMPFoyGFllVFLnna4Q5vqWlBVIOq/8AIX1Z/wDDeB/1K7Zc31T6v25nSMHBx8r7Pd099NlN7mbwXUN2M3V7kKfr9iattwOptH5jmvof8nD9Gkl6lJczV9da8axtH1gwbukWOMNuePUx3H+Tk1f9+XR03VX1ttpe2yt4lj2EOaR4tc1FDNJJJJSkkkklP//X9VSSSSU5H1o627ofSH5zKxZaXNqqa4wwPsO1r7nfm1M/PXNdMf8AVcZA6n1vrGL1Pqrtd77Gmqr/AIPEo+g1rf3122X9k+zv+2+n9nj9J60bI/l+p7FlR9Tf/Nd/4Ckph/zq+rXfqmLP/GBN/wA6vqz/AOWmLH/GBEj6m/8Amu++lKPqb/5rv/AUrPgrRH/zq+rP/lpi/wDbgS/51fVn/wAtMWP+MCJH1M/81330p4+pv/mu/wDAUrPgrRBb9ZvqpdW6q7qOJZW8Q5j3tc0j+U1y5u/qfSPq7Y7qH1b6nRbiEzldGNu5rgT7rMH/AEVv8hdVH1M/81330p2j6n7ht/Z26Rtj0ZntCCXWotbdTXc0ENsaHgHQw4btURJJFCkkkklP/9k4QklNBCEAAAAAAFUAAAABAQAAAA8AQQBkAG8AYgBlACAAUABoAG8AdABvAHMAaABvAHAAAAATAEEAZABvAGIAZQAgAFAAaABvAHQAbwBzAGgAbwBwACAAQwBTADUAAAABADhCSU0EBgAAAAAABwABAAAAAQEA/+EO4Gh0dHA6Ly9ucy5hZG9iZS5jb20veGFwLzEuMC8APD94cGFja2V0IGJlZ2luPSLvu78iIGlkPSJXNU0wTXBDZWhpSHpyZVN6TlRjemtjOWQiPz4gPHg6eG1wbWV0YSB4bWxuczp4PSJhZG9iZTpuczptZXRhLyIgeDp4bXB0az0iQWRvYmUgWE1QIENvcmUgNS4wLWMwNjAgNjEuMTM0Nzc3LCAyMDEwLzAyLzEyLTE3OjMyOjAwICAgICAgICAiPiA8cmRmOlJERiB4bWxuczpyZGY9Imh0dHA6Ly93d3cudzMub3JnLzE5OTkvMDIvMjItcmRmLXN5bnRheC1ucyMiPiA8cmRmOkRlc2NyaXB0aW9uIHJkZjphYm91dD0iIiB4bWxuczp4bXA9Imh0dHA6Ly9ucy5hZG9iZS5jb20veGFwLzEuMC8iIHhtbG5zOnhtcE1NPSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvbW0vIiB4bWxuczpzdEV2dD0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wL3NUeXBlL1Jlc291cmNlRXZlbnQjIiB4bWxuczpkYz0iaHR0cDovL3B1cmwub3JnL2RjL2VsZW1lbnRzLzEuMS8iIHhtbG5zOmNycz0iaHR0cDovL25zLmFkb2JlLmNvbS9jYW1lcmEtcmF3LXNldHRpbmdzLzEuMC8iIHhtbG5zOnBob3Rvc2hvcD0iaHR0cDovL25zLmFkb2JlLmNvbS9waG90b3Nob3AvMS4wLyIgeG1wOkNyZWF0b3JUb29sPSJBZG9iZSBQaG90b3Nob3AgQ1M1IFdpbmRvd3MiIHhtcDpDcmVhdGVEYXRlPSIyMDIyLTA1LTAzVDE2OjQ2OjUyLTAzOjAwIiB4bXA6TWV0YWRhdGFEYXRlPSIyMDIyLTA1LTAzVDE2OjUzLTAzOjAwIiB4bXA6TW9kaWZ5RGF0ZT0iMjAyMi0wNS0wM1QxNjo1My0wMzowMCIgeG1wTU06SW5zdGFuY2VJRD0ieG1wLmlpZDpDMjI3REJBMjFBQ0JFQzExQTBBM0EyNTk5MzFBNzQ2RCIgeG1wTU06RG9jdW1lbnRJRD0ieG1wLmRpZDozQjYzNjNDNzE5Q0JFQzExODEyOEVDM0Y2QzYxNDJEMSIgeG1wTU06T3JpZ2luYWxEb2N1bWVudElEPSJ4bXAuZGlkOjNCNjM2M0M3MTlDQkVDMTE4MTI4RUMzRjZDNjE0MkQxIiBkYzpmb3JtYXQ9ImltYWdlL2pwZWciIGNyczpBbHJlYWR5QXBwbGllZD0iVHJ1ZSIgcGhvdG9zaG9wOkNvbG9yTW9kZT0iMyIgcGhvdG9zaG9wOklDQ1Byb2ZpbGU9InNSR0IgSUVDNjE5NjYtMi4xIj4gPHhtcE1NOkhpc3Rvcnk+IDxyZGY6U2VxPiA8cmRmOmxpIHN0RXZ0OmFjdGlvbj0iY3JlYXRlZCIgc3RFdnQ6aW5zdGFuY2VJRD0ieG1wLmlpZDozQjYzNjNDNzE5Q0JFQzExODEyOEVDM0Y2QzYxNDJEMSIgc3RFdnQ6d2hlbj0iMjAyMi0wNS0wM1QxNjo0Njo1Mi0wMzowMCIgc3RFdnQ6c29mdHdhcmVBZ2VudD0iQWRvYmUgUGhvdG9zaG9wIENTNSBXaW5kb3dzIi8+IDxyZGY6bGkgc3RFdnQ6YWN0aW9uPSJzYXZlZCIgc3RFdnQ6aW5zdGFuY2VJRD0ieG1wLmlpZDozQzYzNjNDNzE5Q0JFQzExODEyOEVDM0Y2QzYxNDJEMSIgc3RFdnQ6d2hlbj0iMjAyMi0wNS0wM1QxNjo0Njo1Mi0wMzowMCIgc3RFdnQ6c29mdHdhcmVBZ2VudD0iQWRvYmUgUGhvdG9zaG9wIENTNSBXaW5kb3dzIiBzdEV2dDpjaGFuZ2VkPSIvIi8+IDxyZGY6bGkgc3RFdnQ6YWN0aW9uPSJzYXZlZCIgc3RFdnQ6aW5zdGFuY2VJRD0ieG1wLmlpZDpDMjI3REJBMjFBQ0JFQzExQTBBM0EyNTk5MzFBNzQ2RCIgc3RFdnQ6d2hlbj0iMjAyMi0wNS0wM1QxNjo1My0wMzowMCIgc3RFdnQ6c29mdHdhcmVBZ2VudD0iQWRvYmUgUGhvdG9zaG9wIENTNSBXaW5kb3dzIiBzdEV2dDpjaGFuZ2VkPSIvIi8+IDwvcmRmOlNlcT4gPC94bXBNTTpIaXN0b3J5PiA8L3JkZjpEZXNjcmlwdGlvbj4gPC9yZGY6UkRGPiA8L3g6eG1wbWV0YT4gICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICA8P3hwYWNrZXQgZW5kPSJ3Ij8+/+IMWElDQ19QUk9GSUxFAAEBAAAMSExpbm8CEAAAbW50clJHQiBYWVogB84AAgAJAAYAMQAAYWNzcE1TRlQAAAAASUVDIHNSR0IAAAAAAAAAAAAAAAEAAPbWAAEAAAAA0y1IUCAgAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAARY3BydAAAAVAAAAAzZGVzYwAAAYQAAABsd3RwdAAAAfAAAAAUYmtwdAAAAgQAAAAUclhZWgAAAhgAAAAUZ1hZWgAAAiwAAAAUYlhZWgAAAkAAAAAUZG1uZAAAAlQAAABwZG1kZAAAAsQAAACIdnVlZAAAA0wAAACGdmlldwAAA9QAAAAkbHVtaQAAA/gAAAAUbWVhcwAABAwAAAAkdGVjaAAABDAAAAAMclRSQwAABDwAAAgMZ1RSQwAABDwAAAgMYlRSQwAABDwAAAgMdGV4dAAAAABDb3B5cmlnaHQgKGMpIDE5OTggSGV3bGV0dC1QYWNrYXJkIENvbXBhbnkAAGRlc2MAAAAAAAAAEnNSR0IgSUVDNjE5NjYtMi4xAAAAAAAAAAAAAAASc1JHQiBJRUM2MTk2Ni0yLjEAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAFhZWiAAAAAAAADzUQABAAAAARbMWFlaIAAAAAAAAAAAAAAAAAAAAABYWVogAAAAAAAAb6IAADj1AAADkFhZWiAAAAAAAABimQAAt4UAABjaWFlaIAAAAAAAACSgAAAPhAAAts9kZXNjAAAAAAAAABZJRUMgaHR0cDovL3d3dy5pZWMuY2gAAAAAAAAAAAAAABZJRUMgaHR0cDovL3d3dy5pZWMuY2gAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAZGVzYwAAAAAAAAAuSUVDIDYxOTY2LTIuMSBEZWZhdWx0IFJHQiBjb2xvdXIgc3BhY2UgLSBzUkdCAAAAAAAAAAAAAAAuSUVDIDYxOTY2LTIuMSBEZWZhdWx0IFJHQiBjb2xvdXIgc3BhY2UgLSBzUkdCAAAAAAAAAAAAAAAAAAAAAAAAAAAAAGRlc2MAAAAAAAAALFJlZmVyZW5jZSBWaWV3aW5nIENvbmRpdGlvbiBpbiBJRUM2MTk2Ni0yLjEAAAAAAAAAAAAAACxSZWZlcmVuY2UgVmlld2luZyBDb25kaXRpb24gaW4gSUVDNjE5NjYtMi4xAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAB2aWV3AAAAAAATpP4AFF8uABDPFAAD7cwABBMLAANcngAAAAFYWVogAAAAAABMCVYAUAAAAFcf521lYXMAAAAAAAAAAQAAAAAAAAAAAAAAAAAAAAAAAAKPAAAAAnNpZyAAAAAAQ1JUIGN1cnYAAAAAAAAEAAAAAAUACgAPABQAGQAeACMAKAAtADIANwA7AEAARQBKAE8AVABZAF4AYwBoAG0AcgB3AHwAgQCGAIsAkACVAJoAnwCkAKkArgCyALcAvADBAMYAywDQANUA2wDgAOUA6wDwAPYA+wEBAQcBDQETARkBHwElASsBMgE4AT4BRQFMAVIBWQFgAWcBbgF1AXwBgwGLAZIBmgGhAakBsQG5AcEByQHRAdkB4QHpAfIB+gIDAgwCFAIdAiYCLwI4AkECSwJUAl0CZwJxAnoChAKOApgCogKsArYCwQLLAtUC4ALrAvUDAAMLAxYDIQMtAzgDQwNPA1oDZgNyA34DigOWA6IDrgO6A8cD0wPgA+wD+QQGBBMEIAQtBDsESARVBGMEcQR+BIwEmgSoBLYExATTBOEE8AT+BQ0FHAUrBToFSQVYBWcFdwWGBZYFpgW1BcUF1QXlBfYGBgYWBicGNwZIBlkGagZ7BowGnQavBsAG0QbjBvUHBwcZBysHPQdPB2EHdAeGB5kHrAe/B9IH5Qf4CAsIHwgyCEYIWghuCIIIlgiqCL4I0gjnCPsJEAklCToJTwlkCXkJjwmkCboJzwnlCfsKEQonCj0KVApqCoEKmAquCsUK3ArzCwsLIgs5C1ELaQuAC5gLsAvIC+EL+QwSDCoMQwxcDHUMjgynDMAM2QzzDQ0NJg1ADVoNdA2ODakNww3eDfgOEw4uDkkOZA5/DpsOtg7SDu4PCQ8lD0EPXg96D5YPsw/PD+wQCRAmEEMQYRB+EJsQuRDXEPURExExEU8RbRGMEaoRyRHoEgcSJhJFEmQShBKjEsMS4xMDEyMTQxNjE4MTpBPFE+UUBhQnFEkUahSLFK0UzhTwFRIVNBVWFXgVmxW9FeAWAxYmFkkWbBaPFrIW1hb6Fx0XQRdlF4kXrhfSF/cYGxhAGGUYihivGNUY+hkgGUUZaxmRGbcZ3RoEGioaURp3Gp4axRrsGxQbOxtjG4obshvaHAIcKhxSHHscoxzMHPUdHh1HHXAdmR3DHeweFh5AHmoelB6+HukfEx8+H2kflB+/H+ogFSBBIGwgmCDEIPAhHCFIIXUhoSHOIfsiJyJVIoIiryLdIwojOCNmI5QjwiPwJB8kTSR8JKsk2iUJJTglaCWXJccl9yYnJlcmhya3JugnGCdJJ3onqyfcKA0oPyhxKKIo1CkGKTgpaymdKdAqAio1KmgqmyrPKwIrNitpK50r0SwFLDksbiyiLNctDC1BLXYtqy3hLhYuTC6CLrcu7i8kL1ovkS/HL/4wNTBsMKQw2zESMUoxgjG6MfIyKjJjMpsy1DMNM0YzfzO4M/E0KzRlNJ402DUTNU01hzXCNf02NzZyNq426TckN2A3nDfXOBQ4UDiMOMg5BTlCOX85vDn5OjY6dDqyOu87LTtrO6o76DwnPGU8pDzjPSI9YT2hPeA+ID5gPqA+4D8hP2E/oj/iQCNAZECmQOdBKUFqQaxB7kIwQnJCtUL3QzpDfUPARANER0SKRM5FEkVVRZpF3kYiRmdGq0bwRzVHe0fASAVIS0iRSNdJHUljSalJ8Eo3Sn1KxEsMS1NLmkviTCpMcky6TQJNSk2TTdxOJU5uTrdPAE9JT5NP3VAnUHFQu1EGUVBRm1HmUjFSfFLHUxNTX1OqU/ZUQlSPVNtVKFV1VcJWD1ZcVqlW91dEV5JX4FgvWH1Yy1kaWWlZuFoHWlZaplr1W0VblVvlXDVchlzWXSddeF3JXhpebF69Xw9fYV+zYAVgV2CqYPxhT2GiYfViSWKcYvBjQ2OXY+tkQGSUZOllPWWSZedmPWaSZuhnPWeTZ+loP2iWaOxpQ2maafFqSGqfavdrT2una/9sV2yvbQhtYG25bhJua27Ebx5veG/RcCtwhnDgcTpxlXHwcktypnMBc11zuHQUdHB0zHUodYV14XY+dpt2+HdWd7N4EXhueMx5KnmJeed6RnqlewR7Y3vCfCF8gXzhfUF9oX4BfmJ+wn8jf4R/5YBHgKiBCoFrgc2CMIKSgvSDV4O6hB2EgITjhUeFq4YOhnKG14c7h5+IBIhpiM6JM4mZif6KZIrKizCLlov8jGOMyo0xjZiN/45mjs6PNo+ekAaQbpDWkT+RqJIRknqS45NNk7aUIJSKlPSVX5XJljSWn5cKl3WX4JhMmLiZJJmQmfyaaJrVm0Kbr5wcnImc951kndKeQJ6unx2fi5/6oGmg2KFHobaiJqKWowajdqPmpFakx6U4pammGqaLpv2nbqfgqFKoxKk3qamqHKqPqwKrdavprFys0K1ErbiuLa6hrxavi7AAsHWw6rFgsdayS7LCszizrrQltJy1E7WKtgG2ebbwt2i34LhZuNG5SrnCuju6tbsuu6e8IbybvRW9j74KvoS+/796v/XAcMDswWfB48JfwtvDWMPUxFHEzsVLxcjGRsbDx0HHv8g9yLzJOsm5yjjKt8s2y7bMNcy1zTXNtc42zrbPN8+40DnQutE80b7SP9LB00TTxtRJ1MvVTtXR1lXW2Ndc1+DYZNjo2WzZ8dp22vvbgNwF3IrdEN2W3hzeot8p36/gNuC94UThzOJT4tvjY+Pr5HPk/OWE5g3mlucf56noMui86Ubp0Opb6uXrcOv77IbtEe2c7ijutO9A78zwWPDl8XLx//KM8xnzp/Q09ML1UPXe9m32+/eK+Bn4qPk4+cf6V/rn+3f8B/yY/Sn9uv5L/tz/bf///+4ADkFkb2JlAGSAAAAAAf/bAIQADAgICAkIDAkJDBELCgsRFQ8MDA8VGBMTFRMTGBEMDAwMDAwRDAwMDAwMDAwMDAwMDAwMDAwMDAwMDAwMDAwMDAENCwsNDg0QDg4QFA4ODhQUDg4ODhQRDAwMDAwREQwMDAwMDBEMDAwMDAwMDAwMDAwMDAwMDAwMDAwMDAwMDAwM/8AAEQgAjwBkAwEiAAIRAQMRAf/dAAQAB//EAT8AAAEFAQEBAQEBAAAAAAAAAAMAAQIEBQYHCAkKCwEAAQUBAQEBAQEAAAAAAAAAAQACAwQFBgcICQoLEAABBAEDAgQCBQcGCAUDDDMBAAIRAwQhEjEFQVFhEyJxgTIGFJGhsUIjJBVSwWIzNHKC0UMHJZJT8OHxY3M1FqKygyZEk1RkRcKjdDYX0lXiZfKzhMPTdePzRieUpIW0lcTU5PSltcXV5fVWZnaGlqa2xtbm9jdHV2d3h5ent8fX5/cRAAICAQIEBAMEBQYHBwYFNQEAAhEDITESBEFRYXEiEwUygZEUobFCI8FS0fAzJGLhcoKSQ1MVY3M08SUGFqKygwcmNcLSRJNUoxdkRVU2dGXi8rOEw9N14/NGlKSFtJXE1OT0pbXF1eX1VmZ2hpamtsbW5vYnN0dXZ3eHl6e3x//aAAwDAQACEQMRAD8A9VSVbqV+Vj4N1+JR9pyK2F1dE7d5H5u6HLmOnfWv6z9UxG5mD0ei2l5LQftTWkOaYcx7HM3Me1JT2CS5j9s/XT/yjp/9i2/+RS/bP10/8o6f/Ytv/kUlPTpLmf2z9dP/ACjp/wDYtv8A5FN+2frp/wCUdP8A7Ft/8ikp6dJcz+2frp/5R0/+xbf/ACKX7Z+uvH7Cp/8AYtv/AJFJT0y5j63fWvJ6HdjYuJRXbdkMfaX3uLKw2vljSPpWuTP679cGMe9/RcdrKwXPccxkNA1c53tXPMf136z5bOt39GqzsAMNWHi23hlbSD+lyPeN129zfp7ED4JHi930XqTeq9KxeotYahk1h/pnWCeRKvLl2dV+uNbG119Bx2MYA1rW5TAABw1oDUB/1r+sdPU8TpuT0ept+afYxmSHuDB/OWv2MOytn7zkbVT16SSSSH//0PVVyGez/mv1v9pMEdF6q8NzmjijIOleWP3a7v8ACrr0DNwsfPxLcPKYLKL2lljD3BSU8hk9f+tI6/f0jGowmlo9XFNxsHq0n6Nlb2u2vf8A6RH+1fXyP5jpv+dasqzp+aSegW2beudG/WehZjtDfjj/ALTuP53t/RWNXRdE6vV1fAZlMb6drSa8ig812t0srcP+pVPmsubHUo1wHuPlkywjE77tL7X9fZ/mOm/59qX2r6+/6Dpv+datz/UpKr9+zeH2MntRcP7V9ff9B03/AD7Vz/XfrH1o5h6R1nIq6fSxotvdg7y+wOHsx22Olzd38ldL1/r37L9HHx6ftXUMqRRRMCB9K2535tTVxTreudS6lf1Qsx7b8Y/ZrKqwQ14b7v0b3bvcyfpqbHzGaUSZEAVp+jJaYxjUquj1+XyV036v0ZWA+y71ce29zzWd53Co/wA225v563ugdX+t9+I7EwqcBzOnO+yuNm9hOwe07a/Z9BZuFn9X6jvr6b06x1tbtlj7HNFdb/8AhXLQOHl9PxavqzgW+r1nqznXZ2S3iqt2l938n2foqUoZc/EY6ccyOGPz8I/SP91YBdmWzd6R9beoPq6lndXZjs6d06axfjl0WXA/zNHqH9L+6tP6qdLyS676wdVbHU+ogFtZ/wABj804zf3fb7rVk9I6Zi9XzqcTFb/2OdAdtqHbJy2/Ttf/AKSul3/TXcq+PFYfBSSSSKH/0fVUkkklOJ9aOiW9Sxa8nBd6XVcB3rYNv8ofSof/AMHf9BcszqbMe1n1qxWGvEynDG+sGGOab2nZ9p2fyXfSXoi4/wCsWGzovUX9bbX6vSeoAUdcxolsO9lebt/k7ttqZOAnExlqCmJrZ3GPY9jXscHNcA5jhqCD9FwQ8rLxsPHfk5VraaKxL7HmAsHodz+j5x+ruTZ6uNY03dHySZFlJ932fd+/T+aqH18flHP6VSytttBNjxVYdtb7Wxs9T+q36KyTy5GU45Ghqb7xHqbImCAXG+sfWOm9W61Vl478huLXT6N1rWmvbLnOY6dXenZuV3FzujYGIG1X1sobro4Eknv++96J0zFtq+0X5jm2ZOY4G0NHsAaNrKmtP5rUX6r9O6a7r3VD9mpsox21Oa97Q4V2HcbGsLva1SSlCQIBlw4wNImxL+XEwn1Sq9EnRMz9ldO6n9Ysyt1dWdY04eOdH2bQa6vZ+9kPKZmN1KuOnMd/2S/WH9Ln3DX7JifuD9zaz2M/l/2FO7qVGbkW/WXMBf0fpTjV0rH75OV9H1Wt/O93tqXSfVXo2RiVXdT6n7ur9SIsynf6Nv8AgsRn8ilqucvi4QZyFSnX+DD9GKJHoNg6nTenYvTMGnAxG7KKGhrR3P7z3fy3u9zlaSSVlYpJJJJT/9L1VJJJJSkO+irIpfRe0WVWtLLGO1Ba4Q5pREklPnt3Sba7HfVTItLLqScv6tZ7jqNvuOI5/wC9X9D+orYtq+s31fyKcrG39SxNzLsXdsezJYDsdW//AAfqfmroPrL0QdY6f6dbvRzcd3rYWQOa7W/Q1/cf9Cxci7PvEfWmio15mIfsn1kwGiDDfb9qaz95n01X5jEZxEo/PDWP/er4SrfYssP6l9VdjVNy+r21uLR6tVbGktJ5Y3Ic7/pKeVhUVmv6odEJpFw9bquWTLmUf4R1tn+nyP8AqFs9W69j4PSm59BGQ7J2twa26m6x/wDNNb/6MWHX03LBb9W6rS7q3Vf1r6wZrdTVSf8AtO138ufSraq3KwlkkZTFQiflA4RKf/oK+fDEUNy3+hYVPW+o1ZtdezoHRv0PSae1lrfbZmuH52z/AAa7RBw8THwsWrExmCuihoZWwcABGWiwqSSSSUpJJJJT/9P1VJJJJSkkkklKXJ9dpZ0f6w4vV2tH2PqpGB1Nn5pLhGLe5v8A4G9dYsH69UC76q5+nuprFzD4Orc20O/6KBUGgfq59X/q8LutBljhgMfbTVbYX11GP+09bvoOe72q79TenW0dOd1LM16j1Z32rJeeQHa0Uj+RVUs762Xuy/qzh1g/8p3YlT/MWFtj/wDqV2DWhrQ1ogAQB5BJK6SSSKFJJJJKUkkkkp//1PVUkkklKSSSSUpZP1s/8TPVP/Ctv/UlayyfrX/4muqf+Fbf+pKSnn+rf8hfVn/w3gf9Su2XE9V/5C+rP/hvA/6ldskEqSSSSQpJJJJSkkkklP8A/9X1VJJJJSkkkklKWT9bP/Ez1T/wrb/1JWssn61/+Jrqn/hW3/qSkp5/qv8AyF9Wf/DeB/1K7ZcT1X/kL6s/+G8D/qV2yQSpJJJJCkkkklKSSSSU/wD/1vVUkkklKSSVTqXVendLxzk9QyGY9XYvOpP7rG/Se7+okptrJ+tn/iZ6p/4Vt/6krM/51dY6j/yD0iy2k/RzM13oVH+Uys/pbEHM6Z9dOqY1uLm9Qw8WjIYWWVUUuedrhDm+paUFUg6r/wAhfVn/AMN4H/UrtlzfVPq/bmdIwcHHyvs93T302U3uZvBdQ3YzdXuQp+v2Jq23A6m0fmOa+h/ycP0aSXqUlzNX11rxrG0fWDBu6RY4w2549THcf5OTV/35dHTdVfW22l7bK3iWPYQ5pHi1zUUM0kkklKSSSSU//9f1VJJJJTkfWjrbuh9IfnMrFlpc2qprjDA+w7Wvud+bUz89c10x/wBVxkDqfW+sYvU+qu13vsaaqv8Ag8Sj6DWt/fXbZf2T7O/7b6f2eP0nrRsj+X6nsWVH1N/813/gKSmH/Or6td+qYs/8YE3/ADq+rP8A5aYsf8YESPqb/wCa776Uo+pv/mu/8BSs+CtEf/Or6s/+WmL/ANuBL/nV9Wf/AC0xY/4wIkfUz/zXffSnj6m/+a7/AMBSs+CtEFv1m+ql1bqruo4llbxDmPe1zSP5TXLm7+p9I+rtjuofVvqdFuITOV0Y27muBPuswf8ARW/yF1UfUz/zXffSnaPqfuG39nbpG2PRme0IJdai1t1NdzQQ2xoeAdDDhu1REkkUKSSSSU//2Q=='>");        
            client.println("<br><p>Click the button below to turn on/off the neon sign</p>");
     
            if (relayStatus==0) {
              client.println("<p><a href=\"/relay/on\"><button class=\"button\">ON</button></a></p>");
            } else {
              client.println("<p><a href=\"/relay/off\"><button class=\"button button2\">OFF</button></a></p>");
            } 
            
            client.println("<i>Made with DFRobot ESP32 Firebeetle</i>");           
            client.println("<i>May 2022, @RoniBandini</i>");           
            client.println("</body></html>");
            

            client.println();
            break;
          } else {  
            currentLine = "";
          }
        } else if (c != '\r') {   
          currentLine += c;       
        }
      }
    }
    // Clear the header variable
    header = "";
    // Close the connection
    client.stop();
    Serial.println("Client disconnected.");
    Serial.println("");
  }
  
}
         